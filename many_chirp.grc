options:
  parameters:
    author: soporte
    generate_options: qt_gui
    id: many_chirp
    output_language: python
    title: many_chirp
  states: {}

blocks:
- name: DC
  id: variable
  parameters:
    value: '15'
  states: {}
- name: IPP
  id: variable
  parameters:
    value: '400e-6'
  states: {}
- name: amp_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: amp_2
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: amp_3
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: chirp_file
  id: variable
  parameters:
    value: '''/home/soporte/Descargas/'' + chirp_param + ''.bin'''
  states: {}
- name: chirp_param
  id: variable
  parameters:
    value: '''many_chirp_ipp_'' + str(IPP) + ''_dc_'' + str(DC) + ''_sr_'' + str(samp_rate) + ''_fc_'' + str(f_central) + ''_bw_'' + str(bw)'
  states: {}
- name: des_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: des_2
  id: variable
  parameters:
    value: '0.00010'
  states: {}
- name: des_3
  id: variable
  parameters:
    value: '0.00020'
  states: {}
- name: f_central
  id: variable
  parameters:
    value: '0'
  states: {}
- name: numSamples
  id: variable
  parameters:
    value: len(desp(des_1,amp_1,IPP,DC,samp_rate,f_central,bw))
  states: {}
- name: numSamples_Chirp
  id: variable
  parameters:
    value: 15*numSamples/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '100'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: chirp_file
    type: complex
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /home/soporte/Descargas/file_create/chirp_rx_2.bin
    type: complex
  states: {state: disabled}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: numSamples
    type: complex
  states: {}
- name: blocks_skiphead_1
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: desp(des_1,amp_1,IPP,DC,samp_rate,f_central,bw)
    vlen: numSamples
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: desp(des_2,amp_2,IPP,DC,samp_rate,f_central,bw)
    vlen: numSamples
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: desp(des_3,amp_3,IPP,DC,samp_rate,f_central,bw)
    vlen: numSamples
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: numSamples
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: numSamples
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: numSamples
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from desf import desp
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '8000'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_skiphead_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_file_sink_1_0, '0']
- [blocks_head_1, '0', blocks_delay_0, '0']
- [blocks_head_1, '0', blocks_file_sink_1, '0']
- [blocks_skiphead_1, '0', blocks_head_1, '0']
- [blocks_vector_source_x_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_vector_to_stream_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_add_xx_0, '1']
- [blocks_vector_to_stream_0_1, '0', blocks_add_xx_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
